BMC_MAIN_VERSION = "1.0"
BMC_EXT_VERSION = "0.000"


DISTRO_VERSION = "${BMC_MAIN_VERSION}"
EXTENDED_VERSION = "${BMC_EXT_VERSION}"

