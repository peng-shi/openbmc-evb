PACKAGECONFIG:dev2500 = "\
    hwmontempsensor \
    fansensor \
    psusensor \
    adcsensor \
    "
