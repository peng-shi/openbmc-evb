OBMC_IMAGE_EXTRA_INSTALL += " \
    dev2500-yaml-config \
    webui-vue \
    ipmitool \
"
